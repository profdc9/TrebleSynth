# Repository profdc9/TrebleSynth

File README.md:

# Treble Synth

A video about the TrebleSynth:  [Video](https://www.youtube.com/watch?v=252Vte4tYh0)

The TrebleSynth is a "Modular Synth on a Chip" based on the Raspberry Pi Pico.  It is a through-hole design that is easy to assemble yourself and uses only inexpensive generic parts that are widely available to minimize costs.  One can create various modules on the chip and interconnect them by specifying which unit takes input from another input, assign the controls of these modules to potentiometers, and then adjust the potentiometers to achieve your desired sound.  It also has a fully capable effects module on the chip as well.  The modular synth supports six note polyphony.

The synth has a 25 key, two-octave keyboard (though external MIDI controllers are highly recommended, as the built-in synth keys are rudimentary and more suitable for testing).  The TrebleSynth accepts notes over serial MIDI input and outputs the synth keyboard presses over the serial MIDI output.  There is also a USB MIDI input/output, and notes can be played from a computer to the TrebleSynth over USB and similarly the synth keyboard presses are sent over the USB MIDI output.  The are two jacks available for expression and selection pedals.

When plugged into a USB port, the TrebleSynth enumerates both as a MIDI device and a COM port.  The COM port interface has a text-based interface that may be used to read and set configuration data from a PC.   Type "HELP" for a list of the commands.  For example, typing "ECONF 0 0" lists all of the current effects configuration data, and "SCONF 0 0" lists all of the current synth configuration data.  The data is output in the form of the commands used to reprogram the same state back into the device, so these may be directly copied into a text file and pasted back into a terminal to recreate the configuration.  At some point I (or some volunteer...) could write a graphical user interface that allows external configuration of the modules.

A peculiarity of the device is that, because it uses potentiometers, when loading a saved configuration, the potentiometers may not be at the same positions when the configuration was saved.  When adjusting a potentiometer, the unit number and type of control is displayed.  In addition, initially after the configuration is loaded, the control does not adjust its corresponding parameter until the control is turned back to the original position it was at when the configuration was saved.  A symbol "O" is shown when the control is adjusted to the point where the parameter is being adjusted again.  The symbols "->" and "<-" show that the control should be turned clockwise ("->") or counterclockwise ("<-") until a dot ("O") is displayed, and likewise if ">" is shown, the control should be turned down until "\*" is displayed.

Each module has a "SourceUnit" and "ControlUnit."  The source unit is the unit that the module receives audio input from, and the control unit is the unit that the module receives parameter data from (for example, to adjust pitch for the VCO or amplitude for the VCA).  The unit number of 1 corresponds a zero-valued source (zero voltage signal source).  A unit number of 2 or above corresponds to the input received from the previous module.  So for example, a SourceUnit for 4 would be the output of unit 3 (which normally is input to unit 4, unless unit 4's SourceUnit is otherwise changed).  For example, the mixer has two SourceUnits, one of which defaults to its own unit number (so that it receives the input from the previous unit), and another that can be set to another previous unit, so that the output of these units can be combined.

The code is all licensed under the zlib license (no warranty, yes commercial and non-commercial use).  The PCB is licensed under CC-BY-SA 4.0.  A new, highly efficient, 15-bit fixed-point precision synthesizer engine, specifically suited for Cortex M0+ processors with no floating point or 64-bit integer multiply or divide, was written for this project.  Because the samples are processed in real time, the lag due to processing is about 100 microseconds.  In order to achieve this, the Pi Pico is overclocked to 250 MHz with no seemingly bad effects.

The type of modules that one can create are:

1. VCO (Voltage Controlled Oscillator).  Eight waveforms are included: sine, half-sine, triangle, sawtooth, 1/2 duty cycle square wave, 1/4 duty cycle square wave, 1/8 duty cycle square wave.  The pitch can be modulated by other modules so that FM synthesis can be performed, or vibrato effects can be created.
2. ADSR (Attack Decay Sustain Release).  A envelope module that can be used to modulate the amplitude of a signal, or output the envelope directly so that, for example, an envelope may be used to modulate the pitch of the signal.
3. VCF (Voltage Controlled Filter).  This is a up to four-pole lowpass filter modeled loosely on the 24 dB/octave Moog ladder filter.  It has an adjustable fixed frequency cutoff, or the frequency cutoff is determined by the note being played (frequency=0).  It also has a resonance adjustment.
4. LFO (Low Frequency Oscillator).  An oscillator with a frequency that does not depend on the note frequency.  This can be used, for example, to implement vibrato and tremolo effects when used to modulate other units.
5. VCA (Voltage Controlled Amplifier).  A voltage controlled amplifier that uses the output of another module to modulate the gain.  Additional gain may be applied with a VCA as well.
6. Mixer.  Can be used to combine the output signals of two modules.  For example, two separate VCO FM synthesis chains can be combined together.  The mixing fraction can be modulated (for example by LFO or ADSR).
7. Ring.  A ring modulator where the signal from one module four-quadrant multiplies another module.
8. VDO (Variable Duty-Cycle Oscillator)  A square or sawtooth wave oscillator with a duty cycle that can be modulated (for example by an ADSR or LFO) to change the timbre.  The pitch can be modulated as well (for vibrato or chirp effects).
9. FOLD (Waveform Folding)  Folds a waveform by applying another periodic waveform to the amplitude of the wave.
10. Noise.  A noise source that can be used to create percussive effects.

Up to 10 modules can be used at a time.  Subtractive and FM synthesis is possible with various configurations of the modules. It also includes these effect taken from the GuitarPico ( https://www.github.com/profdc9/GuitarPico ) project:

1.  Noise Gate
2.  Delay 
3.  Room / Reverb (set up specific echoes at particular delays)
4.  Combine (mix together the signals from several effects)
5.  2nd order Bandpass filter
6.  2nd order Lowpass filter
7.  2nd order Highpass filter
8.  2nd order Allpass filter
9.  Tremolo (amplitude modulated by a low frequency oscillator)
10.  Vibrato (pitch modulated by a low frequency oscillator)
11.  Wah (bandpass filter with center frequency controlled by an external control like a pedal)
12.  AutoWah (bandpass filter with center frequency modulated by a low frequency oscillator)
13.  Envelope (bandpass filter with center frequency modulated by signal amplitude)
14.  Distortion (amplification resulting in saturation of the signal)
15.  Overdrive (selectable threshold for low signal / high signal amplitude gain)
16.  Compressor (amplifies weak signals to equal out overall amplitude of signal)
17.  Ring (ring modulator using low frequency oscillator)
18.  Flanger (pitch modulated by a low frequency oscillator, with feedback and combined with unmodulated signal)
19.  Chorus (pitch modulated by a low frequency oscillator, no feedback and combined with unmodulated signal)
20.  Phaser (signal run through multiple stages of all pass filters, combined with unmodulated signal)
21.  Backwards (plays the last samples backwards for weird swooping effect)
22.  PitchShift (allows shifting the pitch by variable amounts, useful for harmony-like effect)
23.  Whammy (pitch shift based on external control like a pedal)
24.  Octave (rectification and amplification of the signal with extreme distortion)
25.  Sinusoidal Oscillator (built in test signal source)

The effects may be cascaded, to up to 16 in a sequence.  Since the synthesizer has an audio input, at some point I will likely implement audio pass-through so the TrebleSynth can act as a guitar pedal as well like the GuitarPico.

A list of parts is included below, with [LCSC](https://lcsc.com) part numbers (with noted exceptions), minimum quantity order, and prices as of the time of writing (2024-06-24).  For some of the resistors and capacitors, you may be better off buying an assortment kit rather than ordering large quantities.

1.  Raspberry Pi Pico X 1 ($4.00 from Sparkfun DEV-17829, $5.00 from Adafruit 4883)
2.  CD4051 ($0.152/pc, QTY 5 C507164)
3.  LM358 ($0.1167/pc, QTY 5, C434570)
4.  2k resistor 1/4 watt metal film ($0.0085/pc, QTY 100, C410663)
5.  1k resistor 1/4 watt metal film ($0.0060/pc, QTY 100, C713997)
6.  2N3904 ($0.0149/pc, QTY 200, C118538)
7.  16 pin DIP socket ($0.031/pc, QTY 30, C72115)
8.  10 ohm resistor 1/4 watt metal film ($0.0147/pc, QTY 50, C1365579)
9.  PC817 optocoupler ($0.0647/pc, QTY 50, C2840441)
10.  Female straight header ($0.28/pc, QTY 20, C343636)
11.  Male straight header ($0.078/pc, QTY 50, C429959)
12.  6 mm button ($0.011/pc, QTY 100, C5340135)
13.  RK09K 10k potentiometer ($0.69/pc, QTY 20, C209779) - note Aliexpress has much cheaper alternatives
14.  RK09Y 10k potentiometer ($0.42/pc, QTY 1, C470717) - note Aliexpress has much cheaper alternatives
15.  220 ohm resistor 1/4 watt metal film ($0.0094/pc, QTY 100, C127220)
16.  2k2 resistor 1/4 watt metal film ($0.0058/pc, QTY 100, C714002)
17.  4k7 resistor 1/4 watt metal film ($0.0109/pc, QTY 100, C119339)
18.  22k resistor 1/4 watt metal film ($0.0054/pc, QTY 100, C601722)
19.  1M resistor 1/4 watt metal film ($0.0106/pc, QTY 100, C119389)
20.  100k resistor 1/4 watt metal film ($0.0094/pc, QTY 100, C119369)
21.  L7805CV regulator ($0.19/pc, QTY 1, C111887)
22.  2 pin terminal connector ($0.0842/pc, QTY 5, C474881)
23.  MIDI DIN 5-pin female socket ($0.2556/pc, QTY 5, C2939344)
24.  TRS female jack ($0.1536/pc, QTY 5, C145814)
25.  Dc barrel jack power connector ($0.0510, QTY 10, C16214)
26.  SD Card connector ($0.156/pc, QTY 5, C91145)
27.  TL431L ($0.0361/pc, QTY 10, C5155530)
28.  10k resistor 1/4 watt metal film ($0.0102, QTY 50, C57436)
29.  100 pF 50+ V ceramic disc acpacitor ($0.0092/pc, QTY 50, C2761725)
30.  10 nF 50+ V ceramic disc capacitor ($0.0106/pc, QTY 50, C2761727)
31.  100 nF 50+ V ceramic disc capacitor ($0.0117/pc, QTY 50, C254094)
32.  2200 pF 50+ V ceramic disc capacitor ($0.0175/pc, QTY 50, C2976625)
33.  4700 pF 50+ V ceramic disc capacitor ($0.0209/pc, QTY 20, C2896052)
34.  22 nF 50+ V ceramic disc capacitor ($0.0044/pc, QTY 100, C377845)
35.  1000 pF 50+ V ceramic disc capacitor ($0.0092/pc, QTY 100, C2832504)
36.  10 uF 50V+ polarized electrolytic capacitor ($0.0134/pc, QTY 50, C43345)
37.  100 uF 25V+ polarized electrolytic capacitor ($0.0148/pc, QTY 50, C47873)
38.  220 uF 16V+ polarized electrolytic capacitor ($0.0201/pc, QTY 20, C43349)
39.  1N4148 diode ($0.0070/pc, QTY 100, C19190385)
40.  1N5819 Schottky diode ($0.031/pc, QTY 20, C5295404)
41.  470 ohm 1/4 watt metal film ($0.0091/pc, QTY 50, C129899)
42.  22 pF 50+ V ceramic disc capacitor ($0.0092/pc, QTY 50, C2832510)
43.  SSD1306 128x64 OLED display (4 pin I2C version) - available on Aliexpress or Amazon
44.  8 pin DIP socket ($0.0240/pc, QTY 20, C72124)

## KiCad design TrebleSynth/TrebleSynth.kicad_pcb

Parts:
Brd1: SSD1306; 128x64OLED
C1, C6, C14, C18, C21, C24, C25, C39, C40, C47: 100 nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C2, C19, C20, C34, C35, C48: 100 uF; CP_Radial_D5.0mm_P2.50mm
C3: 1000 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4, C5, C7, C10, C11, C15, C16, C17, C38: 10 uF; CP_Radial_D5.0mm_P2.50mm
C8, C12, C36: 22 nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C9: 2200 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C13, C37: 4700 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C22, C31: 10 nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C23, C26, C27: 100 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C32, C33: 220 uF; CP_Radial_D5.0mm_P2.50mm
C46: 22 pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: 1N5819; D_DO-41_SOD81_P7.62mm_Horizontal
D3: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12: MountingHole; MountingHole_3.2mm_M3
J1: INPUT; TerminalBlock_bornier-2_P5.08mm
J2: INPUT; PJ-3240-35mm-stereo
J3: OUTPUT; PJ-3240-35mm-stereo
J5: Barrel_Jack_Switch; BarrelJack_Horizontal
J10, J11: DIN-5_180degree; DIN5Circular
Q4, Q5, Q6: 2N3904; TO-92_Inline_Wide
R1, R8, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R30, R32, R34, R50, R51, R52, R57, R61, R64: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R22, R24, R27, R46, R74: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R21, R45: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R62, R65, R66, R69: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: NC; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R23, R26, R36, R37, R44, R63, R67: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R25, R68: 2k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R28, R29, R31, R33, R35, R49, R53, R54, R55, R56: 2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R58, R59, R60: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 10k; Potentiometer_Big_Small_Combined
U1, U2: LM358; DIP-8_W7.62mm_Socket
U3: Pico; RPi_Pico_SMD_TH
U4: LM7805_TO220; TO-220-3_Vertical
U5: TL431LP; TO-92_Inline_Wide
U7: PC817; DIP-4_W7.62mm
U14: MicroSD_SPI_CD; GCT-MEM2055-00-190-01-A

Connections:
+3V3: C33.1, C47.1, R36.1, R37.2, R44.1, R58.1, R67.1, R74.1, U3.36 (3V3), U14.4 (VDD); also elsewhere on the board
+5V: C14.1, C19.1, C25.1, D1.1 (K), R27.2, R60.1, R61.1, R64.1, R66.1, U2.8 (V+), U3.40 (VBUS); also elsewhere on the board
ADC0: C23.1, U3.31 (GPIO26_ADC0); also elsewhere on the board
ADC1: C27.1, U3.32 (GPIO27_ADC1); also elsewhere on the board
ADC2: C26.1, U3.34 (GPIO28_ADC2); also elsewhere on the board
BIAS: C1.1, C2.1, C8.1, C12.1, C18.1, C36.1, R1.1, R2.2, R6.2, U1.3 (+), U2.3 (+), U2.5 (+)
BUTTON1: U3.25 (GPIO19); also elsewhere on the board
BUTTON2: U3.26 (GPIO20); also elsewhere on the board
BUTTON3: U3.27 (GPIO21); also elsewhere on the board
BUTTON4: U3.29 (GPIO22); also elsewhere on the board
FROMDAC1: C10.1, R34.1, R35.1
FROMDAC2: C16.1, R52.1, R56.1
GND: Brd1.1 (GND), C1.2, C2.2, C3.2, C5.2, C6.2, C14.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.2, C24.1, C25.2, C26.2, C27.2, C31.1, C32.2, C33.2, C34.2, C35.2, C39.2, C40.2, C47.2, C48.2, J1.1, J2.G, J3.G, J5.2, J10.2, J11.2, Q4.1 (E), Q5.1 (E), Q6.1 (E), R2.1, R4.1, R8.1, R12.1, R16.1, R20.1, R21.1, R26.1, R28.2, R45.1, R49.2, R68.1, U1.4 (V-), U2.4 (V-), U3.3 (GND), U3.8 (GND), U3.13 (GND), U3.18 (GND), U3.23 (GND), U3.28 (GND), U3.33 (AGND), U3.38 (GND), U4.2 (GND), U5.2 (A), U14.6 (GND); also elsewhere on the board
MISO: R67.2, U3.6 (GPIO4), U14.7 (DO)
MOSI: U3.5 (GPIO3), U14.3 (DI)
unnamed: Brd1.2 (VCC), C24.2, C32.1, R58.2
unnamed: C3.1, C4.2, R3.1, R4.2
unnamed: C5.1, R5.2
unnamed: C7.1, R9.1
unnamed: C8.2, R9.2, R10.1, R11.2
unnamed: C9.1, R11.1, R12.2, R24.2, U1.1
unnamed: C10.2, C11.2
unnamed: C11.1, R13.1
unnamed: C12.2, R13.2, R14.1, R15.1
unnamed: C13.1, C15.1, R15.2, R16.2, U2.1
unnamed: C15.2, R21.2, R22.2
unnamed: C16.2, C17.2
unnamed: C17.1, R17.1
unnamed: C36.2, R17.2, R18.1, R19.1
unnamed: C37.1, C38.1, R19.2, R20.2, U2.7
unnamed: C38.2, R45.2, R46.2
unnamed: C39.1, J10.G
unnamed: C40.1, J11.G
unnamed: C7.2, C46.1, R7.1, R8.2, RV1.3, U1.7
unnamed: C48.1, R69.2, R74.2, U7.4
unnamed: C21.1, D1.2 (A), U4.3 (VO)
unnamed: D3.2 (A), J10.5, U7.2
unnamed: D3.1 (K), R62.1, U7.1
unnamed: J1.2, J2.T1, R3.2
unnamed: J3.S1, R22.1
unnamed: J3.T1, R46.1
unnamed: J10.4, R62.2
unnamed: J11.4, R66.2
unnamed: J11.5, R65.2
unnamed: Q4.2 (B), R57.1
unnamed: Q4.3 (C), R61.2, R63.2
unnamed: Q5.2 (B), R63.1
unnamed: Q5.3 (C), R64.2, R65.1
unnamed: Q6.2 (B), R68.2, U7.3
unnamed: R28.1, R29.1, R30.2
unnamed: R30.1, R31.1, R32.2
unnamed: R32.1, R33.1, R34.2
unnamed: R49.1, R50.2, R53.1
unnamed: R50.1, R51.2, R54.1
unnamed: R51.1, R52.2, R55.1
unnamed: C9.2, R10.2, U1.2 (-)
unnamed: C4.1, R6.1, U1.5 (+)
unnamed: C46.2, R5.1, R7.2, RV1.1, RV1.2, U1.6 (-)
unnamed: C6.1, C35.1, R1.2, R60.2, U1.8 (V+)
unnamed: C13.2, R14.2, U2.2 (-)
unnamed: C37.2, R18.2, U2.6 (-)
unnamed: R23.1, U3.37 (3V3_EN)
unnamed: R53.2, U3.9 (GPIO6)
unnamed: R54.2, U3.10 (GPIO7)
unnamed: R55.2, U3.11 (GPIO8)
unnamed: R56.2, U3.12 (GPIO9)
unnamed: R29.2, U3.16 (GPIO12)
unnamed: R31.2, U3.17 (GPIO13)
unnamed: R33.2, U3.19 (GPIO14)
unnamed: R35.2, U3.20 (GPIO15)
unnamed: R44.2, U3.30 (RUN)
unnamed: R23.2, U3.39 (VSYS)
unnamed: C20.1, J5.1, U4.1 (VI)
unnamed: C31.2, R25.2, R27.1, R59.1, U5.3 (K)
unnamed: R25.1, R26.2, U5.1 (REF)
RX0: Q6.3 (C), R69.1, U3.2 (GPIO1)
SCK: U3.4 (GPIO2), U14.5 (SCLK)
SCL: Brd1.3 (SCL), R36.2, U3.15 (GPIO11)
SDA: Brd1.4 (SDA), R37.1, U3.14 (GPIO10)
SEL0: U3.21 (GPIO16); also elsewhere on the board
SEL1: U3.22 (GPIO17); also elsewhere on the board
SEL2: U3.24 (GPIO18); also elsewhere on the board
SPICS: U3.7 (GPIO5), U14.2 (~CS)
TOADC: R24.1; also elsewhere on the board
TX0: R57.2, U3.1 (GPIO0)
VREF: C22.2, C34.1, R59.2, U3.35 (ADC_VREF); also elsewhere on the board

Notes on the sheet:
GUITAR PICO BY DANIEL MARKS CC-BY-SA 4.0

Parts:
C28, C29, C30, C41, C42, C43, C44, C45: 100 nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J8, J9: INPUT; PJ-3240-35mm-stereo
JP1, JP2: POWER; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3: 2N3904; TO-92_Inline_Wide
R38, R40, R42: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R39, R41, R70: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R43, R71, R72, R73: 2k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R47, R48: NC; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10, RV11, RV12, RV13, RV14, RV15, RV16, RV17, RV18, RV19, RV20, RV21, RV22: 10k; Potentiometer_Alps_RK09K_Single_Vertical
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32: SW_Push; SW_PUSH_6mm
U6, U8, U9, U10, U11, U12, U13: 4051; DIP-16_W7.62mm_Socket

Connections:
+3V3: R43.1, R71.1, R72.1, R73.1; also elsewhere on the board
+5V: C28.1, C29.1, C30.1, C41.1, C42.1, C43.1, C44.1, C45.1, R39.1, R41.1, R70.1, U6.16 (VDD), U8.16 (VDD), U9.16 (VDD), U10.16 (VDD), U11.16 (VDD), U12.16 (VDD), U13.16 (VDD); also elsewhere on the board
ADC0: D2.2 (A), U8.3 (X); also elsewhere on the board
ADC1: U10.3 (X); also elsewhere on the board
ADC2: U13.3 (X); also elsewhere on the board
BUTTON1: R43.2, U6.3 (X); also elsewhere on the board
BUTTON2: R71.2, U9.3 (X); also elsewhere on the board
BUTTON3: R72.2, U11.3 (X); also elsewhere on the board
BUTTON4: R73.2, U12.3 (X); also elsewhere on the board
CTRLA: Q1.3 (C), R39.2, U6.11 (A), U8.11 (A), U9.11 (A), U10.11 (A), U11.11 (A), U12.11 (A), U13.11 (A)
CTRLB: Q2.3 (C), R41.2, U6.10 (B), U8.10 (B), U9.10 (B), U10.10 (B), U11.10 (B), U12.10 (B), U13.10 (B)
CTRLC: Q3.3 (C), R70.2, U6.9 (C), U8.9 (C), U9.9 (C), U10.9 (C), U11.9 (C), U12.9 (C), U13.9 (C)
GND: C28.2, C29.2, C30.2, C41.2, C42.2, C43.2, C44.2, C45.2, J8.G, J9.G, Q1.1 (E), Q2.1 (E), Q3.1 (E), RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, RV13.1, RV14.1, RV15.1, RV16.1, RV17.1, RV18.1, RV19.1, RV20.1, RV21.1, RV22.1, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, SW16.1, SW17.1, SW18.1, SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, SW24.1, SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, SW30.1, SW31.1, SW32.1, U6.6 (Inh), U6.7 (VEE), U6.8 (VSS), U8.6 (Inh), U8.7 (VEE), U8.8 (VSS), U9.6 (Inh), U9.7 (VEE), U9.8 (VSS), U10.6 (Inh), U10.7 (VEE), U10.8 (VSS), U11.6 (Inh), U11.7 (VEE)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; also elsewhere on the board
unnamed: J8.S1, JP1.1 (A)
unnamed: J9.S1, JP2.1 (A)
unnamed: Q1.2 (B), R38.2
unnamed: Q2.2 (B), R40.2
unnamed: Q3.2 (B), R42.2
unnamed: SW3.2, U6.13 (X0)
unnamed: SW2.2, U6.14 (X1)
unnamed: SW1.2, U6.15 (X2)
unnamed: SW4.2, U6.12 (X3)
unnamed: SW5.2, U6.1 (X4)
unnamed: SW8.2, U6.5 (X5)
unnamed: SW6.2, U6.2 (X6)
unnamed: SW7.2, U6.4 (X7)
unnamed: RV2.2, U8.14 (X1)
unnamed: RV3.2, U8.15 (X2)
unnamed: RV4.2, U8.12 (X3)
unnamed: RV5.2, U8.1 (X4)
unnamed: RV8.2, U8.5 (X5)
unnamed: RV6.2, U8.2 (X6)
unnamed: RV7.2, U8.4 (X7)
unnamed: SW11.2, U9.13 (X0)
unnamed: SW10.2, U9.14 (X1)
unnamed: SW9.2, U9.15 (X2)
unnamed: SW12.2, U9.12 (X3)
unnamed: SW13.2, U9.1 (X4)
unnamed: SW16.2, U9.5 (X5)
unnamed: SW14.2, U9.2 (X6)
unnamed: SW15.2, U9.4 (X7)
unnamed: RV11.2, U10.13 (X0)
unnamed: RV10.2, U10.14 (X1)
unnamed: RV9.2, U10.15 (X2)
unnamed: RV12.2, U10.12 (X3)
unnamed: RV13.2, U10.1 (X4)
unnamed: RV16.2, U10.5 (X5)
unnamed: RV14.2, U10.2 (X6)
unnamed: RV15.2, U10.4 (X7)
unnamed: SW19.2, U11.13 (X0)
unnamed: SW18.2, U11.14 (X1)
unnamed: SW17.2, U11.15 (X2)
unnamed: SW20.2, U11.12 (X3)
unnamed: SW21.2, U11.1 (X4)
unnamed: SW24.2, U11.5 (X5)
unnamed: SW22.2, U11.2 (X6)
unnamed: SW23.2, U11.4 (X7)
unnamed: SW25.2, U12.13 (X0)
unnamed: SW27.2, U12.14 (X1)
unnamed: SW28.2, U12.15 (X2)
unnamed: SW30.2, U12.12 (X3)
unnamed: SW29.2, U12.1 (X4)
unnamed: SW26.2, U12.5 (X5)
unnamed: SW31.2, U12.2 (X6)
unnamed: SW32.2, U12.4 (X7)
unnamed: RV19.2, U13.13 (X0)
unnamed: RV18.2, U13.14 (X1)
unnamed: RV17.2, U13.15 (X2)
unnamed: RV20.2, U13.12 (X3)
unnamed: RV21.2, U13.1 (X4)
unnamed: J8.T1, R47.2, U13.5 (X5)
unnamed: RV22.2, U13.2 (X6)
unnamed: J9.T1, R48.2, U13.4 (X7)
SEL0: R38.1; also elsewhere on the board
SEL1: R40.1; also elsewhere on the board
SEL2: R42.1; also elsewhere on the board
TOADC: U8.13 (X0); also elsewhere on the board
VREF: D2.1 (K), JP1.2 (B), JP2.2 (B), R47.1, R48.1, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, RV13.3, RV14.3, RV15.3, RV16.3, RV17.3, RV18.3, RV19.3, RV20.3, RV21.3, RV22.3; also elsewhere on the board

Board: 2 copper layers, 236.0 x 128.0 mm, 222 parts (0 on the bottom side), 149 nets.

## Code that names these connections

File Code/treblesynth/treblesynth/src/treblesynth.h:

/* treblesynth.h

*/

/*
   Copyright (c) 2024 Daniel Marks

  This software is provided 'as-is', without any express or implied
  warranty. In no event will the authors be held liable for any damages
  arising from the use of this software.

  Permission is granted to anyone to use this software for any purpose,
33  including commercial applications, and to alter it and redistribute it
  freely, subject to the following restrictions:

  1. The origin of this software must not be misrepresented; you must not
   claim that you wrote the original software. If you use this software
   in a product, an acknowledgment in the product documentation would be
   appreciated but is not required.
  2. Altered source versions must be plainly marked as such, and must not be
   misrepresented as being the original software.
  3. This notice may not be removed or altered from any source distribution.
*/

#ifndef _TREBLESYNTH_H
#define _TREBLESYNTH_H

#define PLACE_IN_RAM

#define POTENTIOMETER_MAX 23
#define NUMBER_OF_CONTROLS 64
#define NUMBER_OF_POT_CONTROLS 24
#define NUMBER_OF_CC_CONTROLS (NUMBER_OF_CONTROLS - NUMBER_OF_POT_CONTROLS)
#define CONTROL_VALUE_LENGTH 16

#include "hardware/pio.h"
#include "hardware/pwm.h"
#include "hardware/adc.h"
#include "hardware/dma.h"
#include "hardware/timer.h"
#include "hardware/sync.h"
#include "hardware/flash.h"
#include "hardware/uart.h"
#include "hardware/irq.h"
#include "pico/stdlib.h"
#include "pico/multicore.h"

#define DMB() __dmb()

#define UART_TX_PIN 0
#define UART_RX_PIN 1

#define DAC_PWM_A3 9
#define DAC_PWM_A2 8
#define DAC_PWM_A1 7
#define DAC_PWM_A0 6

#define DAC_PWM_B3 15
#define DAC_PWM_B2 14
#define DAC_PWM_B1 13
#define DAC_PWM_B0 12

#define DAC_PWM_WRAP_VALUE 0x1000

#define ADC_A1 26
#define ADC_A2 27
#define ADC_A3 28
#define ADC_MAX_VALUE 4096
#define ADC_PREC_VALUE 16384

#define GPIO_ADC_SEL0 16
#define GPIO_ADC_SEL1 17
#define GPIO_ADC_SEL2 18

#define GPIO_BUTTON1 19
#define GPIO_BUTTON2 20
#define GPIO_BUTTON3 21
#define GPIO_BUTTON4 22

#define POT_MAX_VALUE 16384u

#define FLASH_BANKS 32
#define FLASH_PAGE_BYTES 4096u
#define FLASH_OFFSET_STORED (2*1024*1024)
#define FLASH_BASE_ADR 0x10000000
#define FLASH_MAGIC_NUMBER 0xFEE1AEDF

#ifndef LED_PIN
#define LED_PIN 25
#endif /* LED_PIN */

#ifdef __cplusplus
extern "C"
{
#endif

uint16_t read_potentiometer_value(uint v);

void set_debug_vals(int32_t v1, int32_t v2, int32_t v3);

#define POTENTIOMETER_VALUE_SENSITIVITY 20
#define PROJECT_MAGIC_NUMBER 0xF00BB00E

#define PROJECT_CONFIGURATION_PAD_LENGTH 256

typedef struct _project_configuration_s
{
  uint32_t  magic_number;
  uint8_t   note_transpose;
  uint8_t   midi_device_no;
  uint32_t  fail_delay;
} project_configuration_s;  

typedef union _project_configuration
{ 
  project_configuration_s pcs;
  uint8_t   pad[PROJECT_CONFIGURATION_PAD_LENGTH];
} project_configuration;

extern project_configuration pc;

#ifdef __cplusplus
}
#endif

#endif /* _TREBLESYNTH_H */

## Commit log

2024-03-31 Added SD card
2024-04-05 Before moving around controls
2024-05-20 Code is added
2024-05-25 Fixes to midi circuit, added midi event handling
2024-06-01 Much work on adding synth
2024-06-03 Modified PCB, working sine synth
2024-06-04 Added ADSR envelope
2024-06-06 Added LPF and Oscillator
2024-06-07 Added more unit types
2024-06-08 improvements here and there
2024-06-08 Before removing interrupt poll
2024-06-08 Remove poll controls from the interrupt loop
2024-06-12 Some synth optimizations
2024-06-13 Added shutoff
2024-06-13 Added DSP effects as well
2024-06-14 Added pitch bend, eliminated RAM sine table
2024-06-16 Some effect improvements
2024-06-19 Minor bound checking fix
2024-06-20 Added noise generator
2024-06-21 Small potentiometer fix
2024-06-23 Added pullup to MOSI
2024-06-24 Added extra 3V3 capacitor
2024-06-25 Added list of parts
2024-06-25 Added some more ground traces
2024-06-26 Fixed some MIDI input issues
2024-06-26 Added VCF fixed frequency and VCF ADSR control
2024-06-28 Added some waveforms
2024-06-29 Tweaked the MIDI serial circuit again
2024-07-02 Added some additional control to mixer
2024-07-04 Modified low pass filter modulation
2024-07-23 Added resonance to lpf
2024-07-25 Simplified call structure
2024-07-27 Added PGET/PSET
2024-07-31 Added VCO
2024-08-01 Added pitch control to VDO
2024-08-20 Added support for MIDI CC controls
2024-08-21 Added folding component
2024-08-31 Added default patches in program
2024-09-04 Added space to save structure
2025-01-03 Changed schematic
